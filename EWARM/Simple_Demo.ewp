# IAR project Simple_Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; MEDIA_IntFLASH
  ICCARM.CCIncludePath2: ..\src; ..\src\Wave; ..\src\FreeRTOS; ..\src\STM32F4-Discovery; ..\src\STM32F4xx_StdPeriph_Driver
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Audio_playback_and_record.bin
  ILINK.IlinkOutputFile: STM32F4-Discovery_FreeRTOS_Demo.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ../src/: startup_stm32f4xx.s
  group FreeRTOS
    ../src/FreeRTOS/: croutine.c heap_2.c list.c port.c portasm.s queue.c tasks.c timers.c
  group STM32F4-Discovery
    ../src/STM32F4-Discovery/: stm32f4_discovery.c stm32f4_discovery_audio_codec.c stm32f4_discovery_lis302dl.c
  group STM32F4xx_StdPeriph_Driver
    ../src/STM32F4xx_StdPeriph_Driver/: misc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c
  group User
    ../src/Wave/: audio_sample.c waveplayer.c
    ../src/: main.c stm32f4xx_it.c system_stm32f4xx.c
